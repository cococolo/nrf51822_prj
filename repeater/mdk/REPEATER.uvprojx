# Keil uVision project REPEATER.uvprojx, settings and files
target repeater (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: REPEATER
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S120 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../src/: repeater_main.c
  group ::Device
    RTE/Device/nRF51422_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAA/: app_error.c app_error.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAA/: s120_nrf51822_2.0.0_licence_agreement.txt softdevice_handler.c
software components: CMSIS:CORE 3.30.0, Device:Startup 7.2.1, nRF_Drivers:nrf_error 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_SoftDevice:Internal:softdevice_present 1.1.3, nRF_SoftDevice:s120 2.0.1
