# Keil uVision project BLE_TEST.uvprojx, settings and files
target BLE_TEST (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_TEST
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_DONGLE SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0  DEBUG
  c include: ..\src
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ../src/: main.c
  group ::Board Support
    RTE/Board_Support/nRF51422_xxAA/: bsp.c bsp_btn_ble.c
  group ::Device
    RTE/Device/nRF51422_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51422_xxAA/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h ble_advertising.c device_manager_cnfg.h
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/ble_services/ble_bas/: ble_bas.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/ble_services/ble_hrs/: ble_hrs.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/ble_services/ble_dis/: ble_dis.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/device_manager/: device_manager_peripheral.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/hal/: nrf_delay.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/common/: nrf_drv_common.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/gpiote/: nrf_drv_gpiote.c
    RTE/nRF_Drivers/nRF51422_xxAA/: app_uart.h nrf_drv_config.h pstorage.c pstorage.h pstorage_platform.h app_uart_fifo.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAA/: app_error.c app_error.h app_timer.c app_timer.h app_trace.c app_trace.h nrf_assert.c nrf_assert.h retarget.c app_fifo.c app_fifo.h app_button.c app_button.h sensorsim.c sensorsim.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAA/: s110_nrf51_8.0.0_licence-agreement.txt softdevice_handler.c
software components: CMSIS:CORE 3.30.0, Board Support:bsp 8.1.1, Board Support:bsp_btn_ble 8.1.1, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.0, nRF_BLE:BLE_Modules:ble_advertising 3.0.0, nRF_BLE:BLE_Modules:ble_common 3.0.0, nRF_BLE:BLE_Modules:ble_conn_params 3.0.0, nRF_BLE:BLE_Modules:ble_service_common 3.0.0, nRF_BLE:BLE_Modules:device_manager 3.0.0, nRF_BLE:BLE_Services:ble_bas 3.0.0, nRF_BLE:BLE_Services:ble_dis 3.0.0, nRF_BLE:BLE_Services:ble_hrs 3.0.0, nRF_Drivers:app_uart 3.0.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_drv_common 3.0.0, nRF_Drivers:nrf_drv_gpiote 3.0.0, nRF_Drivers:nrf_error 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Drivers:nrf_gpiote 3.0.0, nRF_Drivers:pstorage 3.0.0, nRF_Libraries:app_button 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_Libraries:app_fifo 3.0.0, nRF_Libraries:app_timer 3.0.0, nRF_Libraries:app_trace 3.0.0, nRF_Libraries:app_util 3.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_Libraries:retarget 3.0.0, nRF_Libraries:sensorsim 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_SoftDevice:Internal:softdevice_present 1.1.3, nRF_SoftDevice:s110 8.0.1
