# Keil uVision project CentralTest.uvprojx, settings and files
target CentralTest (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CentralTest +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S120 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\src
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group app
    ../src/: central_test.c
  group ::Board Support
    RTE/Board_Support/nRF51422_xxAA/: bsp.c bsp_btn_ble.c
  group ::Device
    RTE/Device/nRF51422_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    RTE/nRF_BLE/nRF51422_xxAA/: ble_db_discovery.c ble_db_discovery.h ble_advdata.c ble_advdata.h device_manager_cnfg.h
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/common/: ble_srv_common.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/device_manager/: device_manager_central.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/ble_services/ble_bas_c/: ble_bas_c.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/3.0.0/ble_services/ble_hrs_c/: ble_hrs_c.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/common/: nrf_drv_common.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/gpiote/: nrf_drv_gpiote.c
    RTE/nRF_Drivers/nRF51422_xxAA/: app_uart.h nrf_drv_config.h pstorage.c pstorage.h pstorage_platform.h app_uart_fifo.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/hal/: nrf_delay.c
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAA/: app_error.c app_error.h app_trace.c app_trace.h nrf_assert.c nrf_assert.h retarget.c app_button.c app_button.h app_timer.c app_timer.h app_fifo.c app_fifo.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAA/: s120_nrf51822_2.0.0_licence_agreement.txt softdevice_handler.c
software components: CMSIS:CORE 3.30.0, Board Support:bsp 8.1.1, Board Support:bsp_btn_ble 8.1.1, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.0, nRF_BLE:BLE_Modules:ble_db_discovery 3.0.0, nRF_BLE:BLE_Modules:ble_service_common 3.0.0, nRF_BLE:BLE_Modules:device_manager 3.0.0, nRF_BLE:BLE_Services:ble_bas_c 3.0.0, nRF_BLE:BLE_Services:ble_hrs_c 3.0.0, nRF_Drivers:app_uart 3.0.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_drv_common 3.0.0, nRF_Drivers:nrf_drv_gpiote 3.0.0, nRF_Drivers:nrf_error 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Drivers:nrf_gpiote 3.0.0, nRF_Drivers:pstorage 3.0.0, nRF_Libraries:app_button 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_Libraries:app_fifo 3.0.0, nRF_Libraries:app_timer 3.0.0, nRF_Libraries:app_trace 3.0.0, nRF_Libraries:app_util 3.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_Libraries:retarget 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_SoftDevice:Internal:softdevice_present 1.1.3, nRF_SoftDevice:s120 2.0.1
