# Keil uVision project TEST.uvprojx, settings and files
target NordicTest (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 wLevel=2
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  c misc: -c99
  c include: ..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../src/: main.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/3.0.0/hal/: nrf_delay.c
software components: CMSIS:CORE 3.30.0, Board Support:bsp 8.1.0, Device:Startup 7.2.1, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_gpio 3.0.0
